#include "font5x7.h"

/* Five bits per row, most significant visible bit at the left. */
static const uint8_t letters[][7] = {
    {14,17,17,31,17,17,17}, /* A */
    {30,17,17,30,17,17,30}, {14,17,16,16,16,17,14},
    {30,17,17,17,17,17,30}, {31,16,16,30,16,16,31},
    {31,16,16,30,16,16,16}, {14,17,16,23,17,17,15},
    {17,17,17,31,17,17,17}, {14,4,4,4,4,4,14},
    {7,2,2,2,18,18,12}, {17,18,20,24,20,18,17},
    {16,16,16,16,16,16,31}, {17,27,21,21,17,17,17},
    {17,25,21,19,17,17,17}, {14,17,17,17,17,17,14},
    {30,17,17,30,16,16,16}, {14,17,17,17,21,18,13},
    {30,17,17,30,20,18,17}, {15,16,16,14,1,1,30},
    {31,4,4,4,4,4,4}, {17,17,17,17,17,17,14},
    {17,17,17,17,17,10,4}, {17,17,17,21,21,21,10},
    {17,17,10,4,10,17,17}, {17,17,10,4,4,4,4},
    {31,1,2,4,8,16,31} /* Z */
};
static const uint8_t digits[][7] = {
    {14,17,19,21,25,17,14}, {4,12,4,4,4,4,14},
    {14,17,1,2,4,8,31}, {30,1,1,14,1,1,30},
    {2,6,10,18,31,2,2}, {31,16,16,30,1,1,30},
    {14,16,16,30,17,17,14}, {31,1,2,4,8,8,8},
    {14,17,17,14,17,17,14}, {14,17,17,15,1,1,14}
};

uint8_t Font5x7_Row(unsigned char c, unsigned row)
{
    static const uint8_t unknown[] = {14,17,1,2,4,0,4};
    if (row >= 7) return 0;
    if (c >= 'a' && c <= 'z') c -= 'a' - 'A';
    if (c >= 'A' && c <= 'Z') return letters[c - 'A'][row];
    if (c >= '0' && c <= '9') return digits[c - '0'][row];
    switch (c) {
    case ' ': return 0;
    case ':': return (row == 2 || row == 5) ? 4 : 0;
    case '-': return row == 3 ? 14 : 0;
    case '+': return row == 3 ? 14 : ((row == 2 || row == 4) ? 4 : 0);
    case '.': return row == 6 ? 4 : 0;
    case '!': return (row < 5 || row == 6) ? 4 : 0;
    case '%': {
        static const uint8_t percent[] = {25,26,2,4,8,11,19};
        return percent[row];
    }
    default: return unknown[row];
    }
}
